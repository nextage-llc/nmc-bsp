# Board name in /etc/hostname and the shell prompt (the default is the machine name, mpfs-icicle-kit)
hostname = "nmc"
