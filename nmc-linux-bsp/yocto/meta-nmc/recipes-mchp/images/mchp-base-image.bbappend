# spidev tools (spi-config, spi-pipe) for SPI0 on J12, same as the Buildroot image.
IMAGE_INSTALL:append = " spitools"
